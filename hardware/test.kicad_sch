File: hardware/test.kicad_sch (KiCad schematic)
At the start: 1 part, among them J2 Debug

Commit message: eja
Parts:
- removed J2: Debug, symbol Connector_Generic:Conn_01x04
